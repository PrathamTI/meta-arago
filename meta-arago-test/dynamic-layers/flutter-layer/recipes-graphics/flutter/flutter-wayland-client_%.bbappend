FLUTTER_ARAGO = ""
FLUTTER_ARAGO:arago = "flutter-wayland-client-arago.inc"

require ${FLUTTER_ARAGO}
